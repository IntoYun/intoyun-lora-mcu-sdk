# Keil uVision project LoRaWan_classC_block.uvprojx, settings and files
target LoRaWan_classC_block (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRaWan_classC_block
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ..\..\..\src\apps\LoRaWan_classC_block\stm32f103rbx\inc;..\..\..\src\hal\stm32f103rbx\inc;..\..\..\src\intoyun\inc;..\..\..\src\mcu\stm32\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\src\mcu\stm32\CMSIS\Include;..\..\..\src\mcu\stm32\STM32F1xx_HAL_Driver\Inc;..\..\..\src\mcu\stm32\STM32F1xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group apps
    ../../../src/apps/LoRaWan_classC_block/stm32f103rbx/src/: main.c startup_stm32f103xb.s stm32f1xx_it.c system_stm32f1xx.c
  group hal
    ../../../src/hal/stm32f103rbx/src/: hal_interface.c
  group intoyun
    ../../../src/intoyun/src/: intoyun_datapoint.c intoyun_interface.c intoyun_protocol.c intoyun_log.c intoyun_key.c intoyun_timer.c
  group mcu
    ../../../src/mcu/stm32/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
software components: CMSIS:CORE 5.0.1
